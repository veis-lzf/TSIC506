# Keil uVision project Measure_Test.uvproj, settings and files
target Measure_Test (MCS-51)
  device: STC15F104E STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: Measure_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\TSIC506;..\BSP\USART;..\BSP\BSP;..\BSP\DELAY
  group USER
    ./: STARTUP.A51 main.c
  group USART
    ../BSP/USART/: uart.c
  group TSIC506
    ../BSP/TSIC506/: tsic506.c
  group DELAY
    ../BSP/DELAY/: delay.c
